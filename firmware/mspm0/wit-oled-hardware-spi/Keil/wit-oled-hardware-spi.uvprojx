# Keil uVision project wit-oled-hardware-spi.uvprojx, settings and files
target MSPM0G3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: wit-oled-hardware-spi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_2_05_01_00\source;C:\ti\mspm0_sdk_2_05_01_00\source\third_party\CMSIS\Core\Include;..;..\Debug;..\App\Chassis;..\App\Control;..\App\Mission;..\App\Runtime;..\Drivers\CAN;..\Drivers\ENCODER;..\Drivers\GRAY;..\Drivers\MOTOR;..\Drivers\MSPM0;..\Drivers\OLED_Hardware_SPI;..\Drivers\PID;..\Drivers\UART_VOFA+;..\Drivers\WIT;..\..\..\..\shared\protocol
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: --keep=hball_stack_extension
  group library
    C:/ti/mspm0_sdk_2_05_01_00/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group application
    ../Drivers/MSPM0/: hball_stack_reserve.s clock.c interrupt.c
    C:/ti/mspm0_sdk_2_05_01_00/source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
    ../: main.c wit-oled-hardware-spi.syscfg
    ../Debug/: ti_msp_dl_config.c
    ../App/Chassis/: route_marker_detector.c
    ../App/Control/: chassis_actuator.c line_snapshot.c line_follower.c wheel_control.c
    ../Drivers/CAN/: hball_can_protocol.c hball_can_recovery.c hball_can_port.c hball_mission_client.c
    ../App/Mission/: hball_mission_menu.c hball_mission_policy.c hball_mission_run_guard.c
    ../App/Runtime/: hball_coop_scheduler.c hball_runtime_dispatcher.c hball_runtime_services.c hball_runtime_target.c
    ../../../../shared/protocol/: hball_mission_can.c
    ../Drivers/ENCODER/: encoder.c
    ../Drivers/GRAY/: beeper.c gray.c key.c led.c line_sensor_port.c track.c
    ../Drivers/MOTOR/: motor.c
    ../Drivers/OLED_Hardware_SPI/: oled_hardware_spi.c
    ../Drivers/PID/: pid.c
    ../Drivers/UART_VOFA+/: uart_vofa.c
    ../Drivers/WIT/: wit_jy901s_config.c wit_parser.c wit_byte_queue.c wit.c
